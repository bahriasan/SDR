options:
  parameters:
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: azimuth_angle
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '90'
    value: '-30'
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458.0'
  states: {}
- name: elevation_angle
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '90'
    value: '55'
  states: {}
- name: elipticity_angle
  id: variable_qtgui_range
  parameters:
    start: '-45'
    step: '1'
    stop: '45'
    value: '0'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 1.575e9
  states: {}
- name: polarization_angle
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1_1
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1_2
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_2
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_3
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_4
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_5
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_6
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_7
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    name: '"probeRate"'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_quantizer_0
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: channels_quantizer_0_0
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: channels_quantizer_0_1
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: channels_quantizer_0_2
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: channels_quantizer_1
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: channels_quantizer_1_0
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: channels_quantizer_1_1
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: channels_quantizer_1_2
  id: channels_quantizer
  parameters:
    bits: '8'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.decim_block):\n    def __init__(self, window_size=4096):\n        self.window_size = int(window_size)\n\n        if self.window_size <= 0:\n            raise ValueError(\"window_size must be positive\")\n\n        gr.decim_block.__init__(\n            self,\n            name=\"SNR Meter Optimized\",\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[np.float32],\n            decim=self.window_size\n        )\n\n    def work(self, input_items, output_items):\n        signal = input_items[0]\n        noise = input_items[1]\n        output = output_items[0]\n\n        n_windows = min(\n            len(output),\n            len(signal) // self.window_size,\n            len(noise) // self.window_size\n        )\n\n        if n_windows == 0:\n            return 0\n\n        n = n_windows * self.window_size\n\n        s = signal[:n].reshape(n_windows, self.window_size)\n        w = noise[:n].reshape(n_windows, self.window_size)\n\n        # |x|^2 = Re(x)^2 + Im(x)^2\n        signal_power = np.sum(\n            s.real * s.real + s.imag * s.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        noise_power = np.sum(\n            w.real * w.real + w.imag * w.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        with np.errstate(divide=\"ignore\", invalid=\"ignore\"):\n            output[:n_windows] = (\n                10.0 * np.log10(signal_power / noise_power)\n            ).astype(np.float32)\n\n        return n_windows\n"
    window_size: '4096'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.decim_block):\n    def __init__(self, window_size=4096):\n        self.window_size = int(window_size)\n\n        if self.window_size <= 0:\n            raise ValueError(\"window_size must be positive\")\n\n        gr.decim_block.__init__(\n            self,\n            name=\"SNR Meter Optimized\",\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[np.float32],\n            decim=self.window_size\n        )\n\n    def work(self, input_items, output_items):\n        signal = input_items[0]\n        noise = input_items[1]\n        output = output_items[0]\n\n        n_windows = min(\n            len(output),\n            len(signal) // self.window_size,\n            len(noise) // self.window_size\n        )\n\n        if n_windows == 0:\n            return 0\n\n        n = n_windows * self.window_size\n\n        s = signal[:n].reshape(n_windows, self.window_size)\n        w = noise[:n].reshape(n_windows, self.window_size)\n\n        # |x|^2 = Re(x)^2 + Im(x)^2\n        signal_power = np.sum(\n            s.real * s.real + s.imag * s.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        noise_power = np.sum(\n            w.real * w.real + w.imag * w.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        with np.errstate(divide=\"ignore\", invalid=\"ignore\"):\n            output[:n_windows] = (\n                10.0 * np.log10(signal_power / noise_power)\n            ).astype(np.float32)\n\n        return n_windows\n"
    window_size: '4096'
  states: {state: disabled}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.decim_block):\n    def __init__(self, window_size=4096):\n        self.window_size = int(window_size)\n\n        if self.window_size <= 0:\n            raise ValueError(\"window_size must be positive\")\n\n        gr.decim_block.__init__(\n            self,\n            name=\"SNR Meter Optimized\",\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[np.float32],\n            decim=self.window_size\n        )\n\n    def work(self, input_items, output_items):\n        signal = input_items[0]\n        noise = input_items[1]\n        output = output_items[0]\n\n        n_windows = min(\n            len(output),\n            len(signal) // self.window_size,\n            len(noise) // self.window_size\n        )\n\n        if n_windows == 0:\n            return 0\n\n        n = n_windows * self.window_size\n\n        s = signal[:n].reshape(n_windows, self.window_size)\n        w = noise[:n].reshape(n_windows, self.window_size)\n\n        # |x|^2 = Re(x)^2 + Im(x)^2\n        signal_power = np.sum(\n            s.real * s.real + s.imag * s.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        noise_power = np.sum(\n            w.real * w.real + w.imag * w.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        with np.errstate(divide=\"ignore\", invalid=\"ignore\"):\n            output[:n_windows] = (\n                10.0 * np.log10(signal_power / noise_power)\n            ).astype(np.float32)\n\n        return n_windows\n"
    window_size: '4096'
  states: {state: disabled}
- name: epy_block_3_2
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.decim_block):\n    def __init__(self, window_size=4096):\n        self.window_size = int(window_size)\n\n        if self.window_size <= 0:\n            raise ValueError(\"window_size must be positive\")\n\n        gr.decim_block.__init__(\n            self,\n            name=\"SNR Meter Optimized\",\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[np.float32],\n            decim=self.window_size\n        )\n\n    def work(self, input_items, output_items):\n        signal = input_items[0]\n        noise = input_items[1]\n        output = output_items[0]\n\n        n_windows = min(\n            len(output),\n            len(signal) // self.window_size,\n            len(noise) // self.window_size\n        )\n\n        if n_windows == 0:\n            return 0\n\n        n = n_windows * self.window_size\n\n        s = signal[:n].reshape(n_windows, self.window_size)\n        w = noise[:n].reshape(n_windows, self.window_size)\n\n        # |x|^2 = Re(x)^2 + Im(x)^2\n        signal_power = np.sum(\n            s.real * s.real + s.imag * s.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        noise_power = np.sum(\n            w.real * w.real + w.imag * w.imag,\n            axis=1,\n            dtype=np.float64\n        ) / self.window_size\n\n        with np.errstate(divide=\"ignore\", invalid=\"ignore\"):\n            output[:n_windows] = (\n                10.0 * np.log10(signal_power / noise_power)\n            ).astype(np.float32)\n\n        return n_windows\n"
    window_size: '4096'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 9.5e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.2e6
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.2e6
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.2e6
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.2e6
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '60'
    min: '-40'
    name: '"SNR"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '60'
    min: '-40'
    name: '"SNR"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '60'
    min: '-40'
    name: '"SNR"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '60'
    min: '-40'
    name: '"SNR"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Fit Quality"'
    size: '1024'
    srate: '586'
    type: float
    ymax: '360'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Elevation"'
    size: '1024'
    srate: '586'
    type: float
    ymax: '360'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Azimuth"'
    size: '1024'
    srate: '586'
    type: float
    ymax: '360'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '3'
    type: ccc
  states: {}
- name: sdr_aoa_estimator_0
  id: sdr_aoa_estimator
  parameters:
    grid_step_deg: '1'
    max_abs_elevation: '85'
    pattern_LL: '''C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_LL_1575.42MHz_gerceklesen_kazanc.txt'''
    pattern_LR: '''C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_LR_1575.42MHz_gerceklesen_kazanc.txt'''
    pattern_UL: '''C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_UL_1575.42MHz_gerceklesen_kazanc.txt'''
    pattern_UR: '''C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_UR_1575.42MHz_gerceklesen_kazanc.txt'''
    window_size: '1024'
  states: {}
- name: sdr_aoa_visualizer_3d_0
  id: sdr_aoa_visualizer_3d
  parameters:
    beam_half_deg: '10.0'
    true_az_deg: azimuth_angle
    true_el_deg: elevation_angle
    update_hz: '1'
  states: {}
- name: sdr_cst_pattern_0
  id: sdr_cst_pattern
  parameters:
    azm_deg: azimuth_angle
    elev_deg: elevation_angle
    ellipticity_deg: elipticity_angle
    pattern_file: '"C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_UL_1575.42MHz_gerceklesen_kazanc.txt"'
    pol_angle_deg: polarization_angle
  states: {}
- name: sdr_cst_pattern_1
  id: sdr_cst_pattern
  parameters:
    azm_deg: azimuth_angle
    elev_deg: elevation_angle
    ellipticity_deg: elipticity_angle
    pattern_file: '"C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_UR_1575.42MHz_gerceklesen_kazanc.txt"'
    pol_angle_deg: polarization_angle
  states: {}
- name: sdr_cst_pattern_2
  id: sdr_cst_pattern
  parameters:
    azm_deg: azimuth_angle
    elev_deg: elevation_angle
    ellipticity_deg: elipticity_angle
    pattern_file: '"C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_LL_1575.42MHz_gerceklesen_kazanc.txt"'
    pol_angle_deg: polarization_angle
  states: {}
- name: sdr_cst_pattern_3
  id: sdr_cst_pattern
  parameters:
    azm_deg: azimuth_angle
    elev_deg: elevation_angle
    ellipticity_deg: elipticity_angle
    pattern_file: '"C:/SDR/WS/SDR/SDR_generic/antenna/c5_klasik_1_LR_1575.42MHz_gerceklesen_kazanc.txt"'
    pol_angle_deg: polarization_angle
  states: {}
- name: sdr_udp_aoa_sender_0
  id: sdr_udp_aoa_sender
  parameters:
    host: '''127.0.0.1'''
    port: '50100'
    send_hz: '10.0'
    true_az_deg: azimuth_angle
    true_el_deg: elevation_angle
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_1, '0', blocks_keep_one_in_n_1, '0']
- [analog_noise_source_x_1_0, '0', blocks_add_xx_1, '0']
- [analog_noise_source_x_1_0, '0', blocks_keep_one_in_n_3, '0']
- [analog_noise_source_x_1_1, '0', blocks_add_xx_2, '0']
- [analog_noise_source_x_1_1, '0', blocks_keep_one_in_n_5, '0']
- [analog_noise_source_x_1_2, '0', blocks_add_xx_3, '0']
- [analog_noise_source_x_1_2, '0', blocks_keep_one_in_n_7, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_1, '0', blocks_complex_to_imag_0_0, '0']
- [blocks_add_xx_1, '0', blocks_complex_to_real_0_0, '0']
- [blocks_add_xx_2, '0', blocks_complex_to_imag_0_1, '0']
- [blocks_add_xx_2, '0', blocks_complex_to_real_0_1, '0']
- [blocks_add_xx_3, '0', blocks_complex_to_imag_0_2, '0']
- [blocks_add_xx_3, '0', blocks_complex_to_real_0_2, '0']
- [blocks_complex_to_imag_0, '0', channels_quantizer_1, '0']
- [blocks_complex_to_imag_0_0, '0', channels_quantizer_1_0, '0']
- [blocks_complex_to_imag_0_1, '0', channels_quantizer_1_1, '0']
- [blocks_complex_to_imag_0_2, '0', channels_quantizer_1_2, '0']
- [blocks_complex_to_real_0, '0', channels_quantizer_0, '0']
- [blocks_complex_to_real_0_0, '0', channels_quantizer_0_0, '0']
- [blocks_complex_to_real_0_1, '0', channels_quantizer_0_1, '0']
- [blocks_complex_to_real_0_2, '0', channels_quantizer_0_2, '0']
- [blocks_float_to_complex_0, '0', sdr_aoa_estimator_0, '0']
- [blocks_float_to_complex_0_0, '0', sdr_aoa_estimator_0, '1']
- [blocks_float_to_complex_0_1, '0', sdr_aoa_estimator_0, '2']
- [blocks_float_to_complex_0_2, '0', sdr_aoa_estimator_0, '3']
- [blocks_keep_one_in_n_0, '0', epy_block_3, '0']
- [blocks_keep_one_in_n_1, '0', epy_block_3, '1']
- [blocks_keep_one_in_n_2, '0', epy_block_3_0, '0']
- [blocks_keep_one_in_n_3, '0', epy_block_3_0, '1']
- [blocks_keep_one_in_n_4, '0', epy_block_3_1, '0']
- [blocks_keep_one_in_n_5, '0', epy_block_3_1, '1']
- [blocks_keep_one_in_n_6, '0', epy_block_3_2, '0']
- [blocks_keep_one_in_n_7, '0', epy_block_3_2, '1']
- [blocks_throttle2_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [channels_quantizer_0, '0', blocks_float_to_complex_0, '0']
- [channels_quantizer_0_0, '0', blocks_float_to_complex_0_0, '0']
- [channels_quantizer_0_1, '0', blocks_float_to_complex_0_1, '0']
- [channels_quantizer_0_2, '0', blocks_float_to_complex_0_2, '0']
- [channels_quantizer_1, '0', blocks_float_to_complex_0, '1']
- [channels_quantizer_1_0, '0', blocks_float_to_complex_0_0, '1']
- [channels_quantizer_1_1, '0', blocks_float_to_complex_0_1, '1']
- [channels_quantizer_1_2, '0', blocks_float_to_complex_0_2, '1']
- [epy_block_3, '0', blocks_null_sink_0, '0']
- [epy_block_3, '0', qtgui_number_sink_0, '0']
- [epy_block_3_0, '0', blocks_null_sink_1, '0']
- [epy_block_3_0, '0', qtgui_number_sink_0_0, '0']
- [epy_block_3_1, '0', blocks_null_sink_2, '0']
- [epy_block_3_1, '0', qtgui_number_sink_0_1, '0']
- [epy_block_3_2, '0', blocks_null_sink_3, '0']
- [epy_block_3_2, '0', qtgui_number_sink_0_2, '0']
- [low_pass_filter_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', low_pass_filter_1_0, '0']
- [low_pass_filter_0, '0', low_pass_filter_1_1, '0']
- [low_pass_filter_0, '0', low_pass_filter_1_2, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_1_1, '0', rational_resampler_xxx_0_1, '0']
- [low_pass_filter_1_2, '0', rational_resampler_xxx_0_2, '0']
- [rational_resampler_xxx_0, '0', sdr_cst_pattern_0, '0']
- [rational_resampler_xxx_0_0, '0', sdr_cst_pattern_1, '0']
- [rational_resampler_xxx_0_1, '0', sdr_cst_pattern_2, '0']
- [rational_resampler_xxx_0_2, '0', sdr_cst_pattern_3, '0']
- [sdr_aoa_estimator_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [sdr_aoa_estimator_0, '0', sdr_aoa_visualizer_3d_0, '0']
- [sdr_aoa_estimator_0, '0', sdr_udp_aoa_sender_0, '0']
- [sdr_aoa_estimator_0, '1', qtgui_time_sink_x_0_0_0_0, '0']
- [sdr_aoa_estimator_0, '1', sdr_aoa_visualizer_3d_0, '1']
- [sdr_aoa_estimator_0, '1', sdr_udp_aoa_sender_0, '1']
- [sdr_aoa_estimator_0, '2', qtgui_time_sink_x_0_0_0, '0']
- [sdr_aoa_estimator_0, '2', sdr_udp_aoa_sender_0, '2']
- [sdr_cst_pattern_0, '0', blocks_add_xx_0, '1']
- [sdr_cst_pattern_1, '0', blocks_add_xx_1, '1']
- [sdr_cst_pattern_2, '0', blocks_add_xx_2, '1']
- [sdr_cst_pattern_3, '0', blocks_add_xx_3, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
